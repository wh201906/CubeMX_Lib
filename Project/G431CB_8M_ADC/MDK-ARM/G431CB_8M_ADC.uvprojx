# Keil uVision project G431CB_8M_ADC.uvprojx, settings and files
target G431CB_8M_ADC (6160000::V6.16::ARMCLANG)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: G431CB_8M_ADC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;   "C:/Users/when how/STM32Cube/Repository/STM32Cube_FW_G4_V1.4.0/Drivers/STM32G4xx_HAL_Driver/Inc";   "C:/Users/when how/STM32Cube/Repository/STM32Cube_FW_G4_V1.4.0/Drivers/STM32G4xx_HAL_Driver/Inc/Legacy";   "C:/Users/when how/STM32Cube/Repository/STM32Cube_FW_G4_V1.4.0/Drivers/CMSIS/Device/ST/STM32G4xx/Include";   "C:/Users/when how/STM32Cube/Repository/STM32Cube_FW_G4_V1.4.0/Drivers/CMSIS/Include";   ../../../Module
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    C:/Users/when how/STM32Cube/Repository/STM32Cube_FW_G4_V1.4.0/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c stm32g4xx_ll_gpio.c stm32g4xx_ll_dma.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Module
    ../../../Module/UTIL/: util.c
    ../../../Module/DELAY/: delay.c
    ../../../Module/UART/: myuart.c
software components: CMSIS:CORE 5.5.0
