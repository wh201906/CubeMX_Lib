# Keil uVision project L051C8_8M_Tx.uvprojx, settings and files
target L051C8_8M_Tx (6160000::V6.16::ARMCLANG)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: L051C8_8M_Tx +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L051xx,STM32_THREAD_SAFE_STRATEGY=2
  c include: ../Core/Inc;   "C:/Users/when how/STM32Cube/Repository/STM32Cube_FW_L0_V1.12.1/Drivers/STM32L0xx_HAL_Driver/Inc";   "C:/Users/when how/STM32Cube/Repository/STM32Cube_FW_L0_V1.12.1/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy";   "C:/Users/when how/STM32Cube/Repository/STM32Cube_FW_L0_V1.12.1/Drivers/CMSIS/Device/ST/STM32L0xx/Include";   "C:/Users/when how/STM32Cube/Repository/STM32Cube_FW_L0_V1.12.1/Drivers/CMSIS/Include";   ../../../Module
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s armlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    C:/Users/when how/STM32Cube/Repository/STM32Cube_FW_L0_V1.12.1/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_ll_tim.c stm32l0xx_ll_gpio.c stm32l0xx_ll_dma.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Module
    ../../../Module/DELAY/: delay.c
    ../../../Module/GRIDKEY/: gridkey.c
    ../../../Module/I2C/: softi2c.c
    ../../../Module/OLED/: oled.c
    ../../../Module/UTIL/: util.c
    ../../../Module/Mod/: mod.c
    ../../../Module/AD9834/: ad9834.c
software components: CMSIS:CORE 5.5.0
